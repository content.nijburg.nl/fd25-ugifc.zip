Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 4cbc3e24-fc09-4aaf-bf7e-697b6f18ab7c, NumberOfSaves: 36]
File name: Project Number
Time: 2024-02-23T10:37:43+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
Port_2179609_1
Port_2179609_2

# IfcFlowController: NLRS_57_DUA_UN_rectangular_firedamper_with_smokesensor_fd25-ug_sacs:FD25 APP EX UG, NLRS_57_DUA_UN_rectangular_firedamper_with_smokesensor_fd25-ug_sacs:FD25 APP EX UG:2179609
In: Default
Type - Description: Rechthoekige brandklep met rooksensor; PredefinedType: FIREDAMPER; Material: Aluminium_Color, NLRS_A_SACS_SVZ, Belimo_Black
Type - Other - Category: Duct Accessories; Family Name: NLRS_57_DUA_UN_rectangular_firedamper_with_smokesensor_fd25-ug_sacs
Type - Constraints - Default Elevation: 0 mm
Type - General - Article_Codes: FD25_UG_Article_Codes; Factors: FD25_Factors
Type - Identity Data - Assembly Code: 57.70; Description: Rechthoekige brandklep met rooksensor; Manufacturer: Solid Air Climate Solutions; Model: Brandklep met rooksensor - Rechthoekig; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 17-01-2022; NLRS_C_content_provider: Solid Air Climate Systems; NLRS_C_content_versie: Versie 3.19.00; NLRS_C_description: Rechthoekige brandklep met rooksensor; NLRS_C_niveau ontwikkeling: LOD400; Type Name: FD25 APP EX UG; URL: https://solid-air.nl/producten/solid-air-rechthoekige-brandklep-fd25/
Type - Materials and Finishes - Blade material: Promatect, 25 or 40mm; Casing material: Galvanized Steel; Fuse temperatuur (default): 72 degrees Celsius
Type - Visibility - Show Symbol: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Classification: 57.70 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FD25 APP EX UG; sets with these values: 2
Other - Family: NLRS_57_DUA_UN_rectangular_firedamper_with_smokesensor_fd25-ug_sacs; Family and Type: NLRS_57_DUA_UN_rectangular_firedamper_with_smokesensor_fd25-ug_sacs: FD25 APP EX UG; Type: FD25 APP EX UG; Type Id: 2178895
Model Properties - Attached Smokesensor (standard): yes; SACS_Air_Velocity: 0 m/s; SACS_Belimo_Rotation (1-2): 1; SACS_Option_1: APP = Applique frame; SACS_Option_2: EX = Schischek 230/24 servo explosieveilig; SACS_Option_3: O = Geen Accessoire
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.210148 m2; NLRS_C_lengte: 765 mm; NLRS_M_c01_breedte: 500 mm; NLRS_M_c01_hoogte: 450 mm; SACS_Duct_Height: 450 mm; SACS_Duct_Width: 500 mm; Size: 500x450-500x450; Volume: 0.000190248 m3
Graphics - Use Annotation Scale: no
Identity Data - Mark: 693; NLRS_C_model: FD25 APP EX UG 500x450; SACS_Article_Code: NB; SACS_Gross_Cost: 0; SACS_Price_Date: 0
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; System Classification: Undefined
Mechanical - Flow - NLRS_M_c01_debiet: 0 dm3/s; SACS_Lp_dBA: 0; SACS_Manual_Airflow: 0 dm3/s; SACS_Nominal_Max_Flow: 2250 dm3/s; SACS_Nominal_Min_Flow: 450 dm3/s; SACS_Use_Manual_Airflow: yes
Phasing - Phase Created: New Construction
Visibility - SACS_Disable_Warning: yes; Show_recommended_placement_zone: yes
Insulation - Insulation Thickness: 0 mm; Overall Size: 500 mmx450 mm-500 mmx450 mm
Lining - Free Size: 500 mmx450 mm-500 mmx450 mm; Lining Thickness: 0 mm
